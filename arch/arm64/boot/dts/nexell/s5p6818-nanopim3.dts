/*
 * Copyright (C) 2016  Nexell Co., Ltd.
 * Author: Youngbok, Park <ybpark@nexell.co.kr>
 *
 * This program is free software; you can redistribute it and/or
 * modify it under the terms of the GNU General Public License
 * as published by the Free Software Foundation; either version 2
 * of the License, or (at your option) any later version.
 *
 * This program is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 * GNU General Public License for more details.
 *
 * You should have received a copy of the GNU General Public License
 * along with this program.  If not, see <http://www.gnu.org/licenses/>.
 */

/dts-v1/;
#include <dt-bindings/interrupt-controller/irq.h>
#include <dt-bindings/gpio/gpio.h>
#include <dt-bindings/thermal/thermal.h>
#include "s5p6818.dtsi"

#define PMIC_PDATA_INIT(_id, _rname, _minuv,	\
			_maxuv, _always_on, _boot_on,		\
			_init_uv, _init_enable, _slp_slots)	\
		regulator-name = _rname;		\
		regulator-min-microvolt = <_minuv>;	\
		regulator-max-microvolt = <_maxuv>;	\
		nx,id = <_id>;				\
		nx,always_on = <_always_on>;		\
		nx,boot_on = <_boot_on>;		\
		nx,init_enable = <_init_enable>;	\
		nx,init_uV = <_init_uv>;		\
		nx,sleep_slots = <_slp_slots>;

/ {
	model = "FriendlyElec NanoPC-T3";
	compatible = "friendlyelec,nanopc-t3", "nexell,s5p6818";

	chosen {
		bootargs = "console=tty0 console=ttySAC0,115200n8 earlycon=s5p6818,0xc00a1000";
		/*bootargs = "console=tty0 console=ttySAC0,115200n8 rdinit=/init";*/
		stdout-path = "serial0:115200n8";
	};

	memory@40000000 {
		device_type = "memory";
		reg = <0x40000000 0x7db00000>;
	};

	mach: board {
		compatible = "friendlyelec,board";
		machine = "NANOPCT3";
		hwrev = <1>;
		model = "NanoPC T3 Series";
	};
};

&soc {

	aliases {
		ethernet0 = &gmac0;
	};

	/* FIXME: bluetooth reset is piggybacked here although their data flow
	* goes through serial1 */
	wifi_powerseq: wifi_powerseq  {
		compatible = "mmc-pwrseq-simple";
		reset-gpios = <&gpio_b 24 GPIO_ACTIVE_LOW		/* wifi */
				&gpio_b 8 GPIO_ACTIVE_LOW>;		/* bluetooth */
		post-power-on-delay-ms = <50>;
	};

	i2c3_gpio:i2c@3 {
		compatible = "i2c-gpio";
		gpios = <&gpio_e 31 0	/* sda */
			&gpio_e 30 0	/* scl */
			>;
		i2c-gpio,delay-us = <10>;/* ~100 kHz */
		i2c-gpio,ch =<3>;

		#address-cells = <1>;
		#size-cells = <0>;

		spu1705@2d {
			compatible = "spu1705,fe-pmu";
			reg = <0x2d>;
			regulators {
				VCC1P1_ARM_SPU: DCDC1 {
					regulator-name = "vdd_arm_1.3V";
					regulator-min-microvolt = <905000>;
					regulator-max-microvolt = <1265000>;
					regulator-always-on;
				};
			};
		};

		axp228@34 {
			compatible = "x-powers,axp228";
			reg = <0x34>;
			interrupt-parent = <&alive_0>;	// CFG_GPIO_PMIC_INTR
			interrupts = <0x4 IRQ_TYPE_EDGE_FALLING>;
			nx,id = <0>;
			/* vdd_arm-supply = <&VCC1P1_ARM_PMIC>; */
			/* vdd_core-supply = <&VCC1P0_CORE_PMIC>; */
			regulators {
				VCC_LDO1:
					axp22_rtcldo{PMIC_PDATA_INIT(0,
					"axp228_rtcldo",
					3000000, 3000000, 0, 0, 3300000,
					0, 0xF) };
				VCC_LDO2:
					axp22_aldo1{PMIC_PDATA_INIT(1,
					"axp228_3p3_alive",
					700000, 3300000, 1, 1, 3300000,
					1, 0xF) };
				VCC_LDO3:
					axp22_aldo2{PMIC_PDATA_INIT(2,
					"axp228_1p8_alive",
					700000, 3300000, 1, 1, 1800000,
					1, 0xF) };
				VCC_LDO4:
					axp22_aldo3{PMIC_PDATA_INIT(3,
					"axp228_1p0_alive",
					700000, 3300000, 1, 1, 1000000,
					1, 0xF) };
				VCC_LDO5:
					axp22_dldo1{PMIC_PDATA_INIT(4,
					"axp228_wide",
					700000, 3300000, 1, 1, 3300000,
					1, 0xF) };
				VCC_LDO6:
					axp22_dldo2{PMIC_PDATA_INIT(5,
					"axp228_1p8_cam",
					700000, 3300000, 0, 0, 1800000,
					0, 0xF) };
				VCC_LDO7:
					axp22_dldo3{PMIC_PDATA_INIT(6,
					"axp228_dldo3",
					700000, 3300000, 0, 0,  700000,
					0, 0xF) };
				VCC_LDO8:
					axp22_dldo4{PMIC_PDATA_INIT(7,
					"axp228_dldo4",
					700000, 3300000, 0, 0,  700000,
					0, 0xF) };
				VCC_LDO9:
					axp22_eldo1{PMIC_PDATA_INIT(8,
					"axp228_1p8_sys",
					700000, 3300000, 1, 1, 1800000,
					1, 0xF) };
				VCC_LDO10:
					axp22_eldo2{PMIC_PDATA_INIT(9,
					"axp228_3p3_wifi",
					700000, 3300000, 1, 1, 3300000,
					1, 0xF) };
				VCC_LDO11:
					axp22_eldo3{PMIC_PDATA_INIT(10,
					"axp228_eldo3",
					700000, 3300000, 0, 0,  700000,
					0, 0xF) };
				VCC_LDO12:
					axp22_dc5ldo{PMIC_PDATA_INIT(11,
					"axp228_1p2_cvbs",
					700000, 1400000, 0, 0, 1200000,
					0, 0xF) };
				VCC_DCDC1:
					axp22_dcdc1{PMIC_PDATA_INIT(12,
					"axp228_3p3_sys",
					1600000, 3400000, 1, 1, 3300000,
					1, 0xF) };
				VCC1P1_ARM_PMIC:
					axp22_dcdc2{PMIC_PDATA_INIT(13,
					"axp228_1p1_arm",
					600000, 1540000, 1, 1, 1200000,
					1, 0xF) };
				VCC1P0_CORE_PMIC:
					axp22_dcdc3{PMIC_PDATA_INIT(14,
					"axp228_1p0_core",
					600000, 1860000, 1, 1, 1200000,
					1, 0xF) };
				VCC_DCDC4:
					axp22_dcdc4{PMIC_PDATA_INIT(15,
					"axp228_1p5_sys",
					600000, 1540000, 1, 1, 1500000,
					1, 0xF) };
				VCC_DCDC5:
					axp22_dcdc5{PMIC_PDATA_INIT(16,
					"axp228_1p5_ddr",
					1000000, 2550000, 1, 1, 1500000,
					1, 0xF) };
				VCC_LDOIO0:
					axp22_ldoio0{PMIC_PDATA_INIT(17,
					"axp228_ldoio0",
					700000, 3300000, 0, 0, 1800000,
					0, 0xF) };
				VCC_LDOIO1:
					axp22_ldoio1{PMIC_PDATA_INIT(18,
					"axp228_ldoio1",
					700000, 3300000, 0, 0, 1000000,
					0, 0xF) };
			};
		};
	};

	nanopi-thermistor {
		compatible = "friendlyarm,nanopi-thermistor";
		status = "okay";

		io-channels = <&adc 2>;
		io-channel-names = "nanopi-thermistor";
	};

	/*gpio_key: gpio_keys {
		compatible = "gpio-keys";
		#address-cells = <1>;
		#size-cells = <0>;
		pinctrl-names = "default";
		pinctrl-0 = <&key_power>;

		power {
			label = "Power";
			gpios = <&alive_0 0 GPIO_ACTIVE_LOW>;
			linux,code = <KEY_POWER>;
			gpio-key,wakeup;
		};
	};*/

	leds: gpio-leds {
		compatible = "gpio-leds";
		pinctrl-names = "default";
		pinctrl-0 =<&led1_gpio>;

		led@1 {
			gpios = <&gpio_b 12 GPIO_ACTIVE_LOW>;
			label = "status_led";
			linux,default-trigger = "heartbeat";
			linux,default-trigger-delay-ms = <0>;
		};
	};

	panel_rgb: panel_rgb {
		compatible = "lcds";
		/*compatible = "nanopi,nano-panel";*/
		status = "okay";
		lcd = "S430";
		
		pinctrl-names = "default";
		pinctrl-0 = <&dp_rgb_vclk &dp_rgb_vsync &dp_rgb_hsync
				&dp_rgb_de &dp_rgb_R &dp_rgb_G &dp_rgb_B>;
		
		port {
			rgb_panel: endpoint {
				remote-endpoint = <&lcd_rgb>;
			};
		};
	};

	spdif_out: spdif-out {
		#sound-dai-cells = <0>;
		compatible = "linux,spdif-dit";
	};

	simple_card: sound {
		compatible = "nexell,simple-audio-card";
		simple-audio-card,name = "nanopi3-audio";
		simple-audio-card,mclk-fs = <256>;
		simple-audio-card,widgets =
			"Headphone", "Out Jack";
		simple-audio-card,routing =
			"Out Jack", "HPOL",
			"Out Jack", "HPOR";
		status = "okay";

		simple-audio-card,dai-link@0 {
			format = "i2s";
			cpu {
				sound-dai = <&i2s_0 0>;
			};

			codec {
				sound-dai = <&es8316_codec>;
			};
		};

		simple-audio-card,dai-link@1 {
			cpu {
				sound-dai = <&spdif_tx 0>;
			};

			codec {
				sound-dai = <&spdif_out>;
			};
		};
	};

	wlan {
		compatible = "samsung,brcm-wlan";
		gpios = <&gpio_b 24 0  /* WLAN_EN */
			 &gpio_c 17 0>; /* WLAN_HOST_WAKE */
		status = "okay";
	};

	bt_bcm {
		compatible = "broadcom,bcm4343";
		reset-gpios = <&gpio_b 8 0>;
		rts-gpios = <&gpio_c 6 0>;
		cts-gpios = <&gpio_c 5 0>;
		pinctrl-names = "default", "gpios";
		pinctrl-0 = <&bt_cfg_en>, <&serial1_flow>;
		pinctrl-1 = <&bt_cfg_en>, <&bt_flow_gpio>;
		status = "okay";
	};

	nexell-ion@0 {
		compatible = "nexell,ion";

		heap_sys_user@0 {
			heap-type = "ion_system";
		};

		heap_sys_contig@0 {
			heap-type = "ion_system_contig";
		};

		heap_dma@0 {
			heap-type = "ion_dma";
		};
	};

	wifi_bcm4329 {
		compatible = "nanopi,bcm4329";
		interrupt-parent = <&gpio_c>;
		interrupts = <17 IRQ_TYPE_LEVEL_HIGH>;
	};

	nanopi-onewire {
		interrupt-parent = <&gic>;
		compatible = "friendlyarm,onewire";

		channel-gpio = <&gpio_c 15 0>;
		reg = <PHYS_BASE_TIMER 0x1000>;
		interrupts = <0 IRQ_TIMER3 0>;
		irq-timer = <3>;
	};

	onewire-touch {
		compatible = "friendlyarm,onewire-touch";
		interrupt-parent = <&gpio_c>;
		interrupts = <16 IRQ_TYPE_NONE>;
		i2c-bus = <&i2c_2>;
		pinctrl-names = "default";
		pinctrl-0 = <&touchpanel_irq>;
	};
};

&uart0 {
	clock-frequency = <147500000>;
};
&uart1 {
	clock-frequency = <147500000>;
};
&uart2 {
	clock-frequency = <147500000>;
};
&uart3 {
	clock-frequency = <147500000>;
};
&uart4 {
	clock-frequency = <147500000>;
};
&uart5 {
	clock-frequency = <147500000>;
};
&i2c0 {
	clock-frequency = <200000000>;
};
&i2c1  {
	clock-frequency = <200000000>;
};
&i2c2  {
	clock-frequency = <200000000>;
};
&spi0 {
	clock-frequency = <100000000>;
};
&spi2 {
	clock-frequency = <100000000>;
};
&pwm0 {
	clk-input = <I_PLL2>;
	clock-frequency = <10000000>;
};
&pwm1 {
	clk-input = <I_PLL2>;
	clock-frequency = <10000000>;
};
&pwm2 {
	clk-input = <I_PLL2>;
	clock-frequency = <10000000>;
};
&pwm3 {
	clk-input = <I_PLL2>;
	clock-frequency = <10000000>;
};
&vip1 {
	src-force = <4>;
};

&serial0 {
	status ="okay";
};
&serial1 {
	status ="okay";
	pinctrl-names = "default";
	pinctrl-0 = <&serial1_pin &serial1_flow>;
};
&pl08xdma0 {
	use_isr;
	ch12 {
		slave_wait_flush_dma;
	};
	ch13 {
		slave_wait_flush_dma;
	};
	ch14 {
		slave_wait_flush_dma;
	};
	ch15 {
		slave_wait_flush_dma;
	};
};
&pl08xdma1 {
	use_isr;
	ch0 {
		slave_wait_flush_dma;
	};
	ch1 {
		slave_wait_flush_dma;
	};
};
&pinctrl_0 {
	key_power: key_power {
		nexell,pins = "alive-0";
		nexell,pin-function = <0>;
		nexell,pin-pull = <1>;
		nexell,pin-strength = <0>;
	};

	onewire_pin: onewire-pin {
		nexell,pins = "gpioc-15";
		nexell,pin-function = <1>;
		nexell,pin-pull = <2>;
		nexell,pin-strength = <0>;
	};

	touchpanel_irq: touchpanel-irq {
		nexell,pins = "gpioc-16";
		nexell,pin-function = <1>;
		nexell,pin-pull = <2>;
		nexell,pin-strength = <0>;
	};

	bt_flow_gpio: bt_flow_gpio {
		nexell,pins = "gpioc-5", "gpioc-6";
		nexell,pin-function = <1>;
		nexell,pin-pull = <2>;
		nexell,pin-strength = <0>;
	};

	bt_cfg_en: bt_cfg_en {
		nexell,pins = "gpiob-8";
		nexell,pin-function = <0>;
		nexell,pin-pull = <2>;
		nexell,pin-strength = <0>;
	};

	cfg_wlanen: cfg-wlanen {
		nexell,pins ="gpiob-24";
		nexell,pin-function = <1>;
		nexell,pin-pull = <2>;
		nexell,pin-strength = <0>;
		nexell,pin-dir = <1>;
		nexell,pin-val = <1>;
	};

	cfg_wlanhostwake: cfg-wlanhostwake {
		nexell,pins = "gpioc-17";
		nexell,pin-function = <2>;
		nexell,pin-pull = <0>;
		nexell,pin-strength = <0>;
	};

	led1_gpio: leds-gpio {
		nexell,pins ="gpiob-12";
		nexell,pin-function = <2>;
		nexell,pin-pull = <2>;
		nexell,pin-strength = <0>;
	};
};
&dw_mmc_0 {
	num-slots = <1>;
	bus-width = <4>;		// MMC_CAP_4_BIT_DATA
	cap-sd-highspeed;		// DW_MCI_QUIRK_HIGHSPEED
	cap-mmc-highspeed;		// also DW_MCI_QUIRK_HIGHSPEED
	clock-frequency = <100000000>;	// bus_hz: 100 * 1000 * 1000
	card-detect-delay = <200>;	// detect_delay_ms
	disable-wp;		        // write protect: -> get_ro; not use for micro SD
	cd-gpios = <&alive_0 1 0>;      //卡检测 <&alive_0 1 GPIO_ACTIVE_LOW>
	// card detect: CFG_SDMMC0_DETECT_IO == PAD_GPIO_ALV + 1
	cd-inverted;                    // CD line is active high
	nexell,drive_dly = <0x0>;	// DW_MMC_DRIVE_DELAY(0)
	nexell,drive_shift = <0x02>;	// DW_MMC_DRIVE_PHASE(2)
	nexell,sample_dly = <0x00>;	// DW_MMC_SAMPLE_DELAY(0)
	nexell,sample_shift = <0x01>;	// DW_MMC_SAMPLE_PHASE(1)
	status = "okay";
};
&dw_mmc_1 {
	bus-width = <4>;
	cap-sd-highspeed;
	clock-frequency = <100000000>;
	card-detect-delay = <200>;
	non-removable;
	keep-power-in-suspend;
	nexell,drive_dly = <0x0>;
	nexell,drive_shift = <0x02>;
	nexell,sample_dly = <0x00>;
	nexell,sample_shift = <0x01>;
	mmc-pwrseq = <&wifi_powerseq>;
	status = "okay";

	/* wifi definition for brcmfmac.ko module */
	brcmf: bcrmf@1 {
		compatible = "brcm,bcm4329-fmac";
		reg = <1>;
		interrupt-parent = <&gpio_c>;
		interrupts = <17 IRQ_TYPE_LEVEL_HIGH>;
		brcm,powersave-default-off;
	};
};
&dw_mmc_2 {
	bus-width = <4>;		// MMC_CAP_4_BIT_DATA
	cap-sd-highspeed;		// DW_MCI_QUIRK_HIGHSPEED
	cap-mmc-highspeed;		// also DW_MCI_QUIRK_HIGHSPEED
	//sd-uhs-ddr50;			// MMC_CAP_UHS_DDR50
	//cap-mmc-hw-reset;		// MMC_CAP_HW_RESET
	clock-frequency = <200000000>;	// bus_hz: 200 * 1000 * 1000
	card-detect-delay = <200>;	// detect_delay_ms
	non-removable;			// MMC_CAP_NONREMOVABLE
	broken-cd;
	//cd-gpios = <&gpio_c 24 GPIO_ACTIVE_LOW>;
	disable-wp;
	nexell,drive_dly = <0x0>;	// DW_MMC_DRIVE_DELAY(0)
	nexell,drive_shift = <0x03>;	// DW_MMC_DRIVE_PHASE(3)
	nexell,sample_dly = <0x00>;	// DW_MMC_SAMPLE_DELAY(0)
	nexell,sample_shift = <0x02>;	// DW_MMC_SAMPLE_PHASE(2)
	status = "okay";
};
&watchdog {
	status = "okay";
};
&nexell_usbphy {
	status = "okay";
};
&ehci {
	status = "okay";
	port@0 {
		status = "okay";
	};
};
&ohci {
	status = "okay";
	port@0 {
		status = "okay";
	};
};
&dwc2otg {
	status = "okay";
};
&i2c_0 {
	#address-cells = <1>;
	#size-cells = <0>;
	status = "okay";

	es8316_codec: es8316@11 {
		#sound-dai-cells = <0>;
		compatible = "everest,es8316";
		reg = <0x11>;
	};
};
&i2c_1 {
	status = "okay";
};
&i2c_2 {
	samsung,i2c-max-bus-freq = <200000>;
	#address-cells = <1>;
	#size-cells = <0>;
	status = "okay";

	onewire_ts@2f {
		compatible = "onewire";
		reg = <0x2f>;
		interrupt-parent = <&gpio_c>;
		interrupts = <16 IRQ_TYPE_EDGE_FALLING>;
		pinctrl-names = "default";
		pinctrl-0 = <&touchpanel_irq>;
	};

	ft5x06_ts@38 {
		compatible = "edt,edt-ft5x06", "ft5x06";
		reg = <0x38>;
		interrupt-parent = <&gpio_c>;
		interrupts = <16 IRQ_TYPE_EDGE_FALLING>;
	};

	goodix_ts@5d {
		compatible = "goodix,gt9xx";
		reg = <0x5d>;
		interrupt-parent = <&gpio_c>;
		interrupts = <16 IRQ_TYPE_EDGE_FALLING>;
		goodix,irq-gpio = <&gpio_c 16 0>;
	};

	goodix_ts@14 {
		compatible = "goodix,gt9xx";
		reg = <0x14>;
		interrupt-parent = <&gpio_c>;
		interrupts = <16 IRQ_TYPE_EDGE_FALLING>;
		goodix,irq-gpio = <&gpio_c 16 0>;
	};

	hx8528a_ts@48 {
		compatible = "himax,hx8528-a";
		reg = <0x48>;
		interrupt-parent = <&gpio_c>;
		interrupts = <16 IRQ_TYPE_EDGE_FALLING>;
	};

	it7260_ts@46 {
		compatible = "ite,it7260";
		reg = <0x46>;
		interrupt-parent = <&gpio_c>;
		interrupts = <16 IRQ_TYPE_EDGE_FALLING>;
	};

	st1572_ts@55 {
		compatible = "sitronix,st1572";
		reg = <0x55>;
		interrupt-parent = <&gpio_c>;
		interrupts = <16 IRQ_TYPE_EDGE_FALLING>;
	};
};
&pwm {
	// block pwm3_pin - conflicts with spi0_miso (on spi0_bus) drawn on 2.54mm header
	pinctrl-0 = <&pwm0_pin &pwm1_pin &pwm2_pin>;
	samsung,pwm-outputs = <0>, <1>, <2>;
	status = "okay";
};
&vip_1 {
	status = "okay";
};
&clipper_1 {
	status = "okay";
	pwms = <&pwm 1 41 0>; /* 1000000000/41 */
	interface_type = <NX_CAPTURE_INTERFACE_PARALLEL>;
	pinctrl-names = "default";
	pinctrl-0 = <&vid1_data_clk &vid1_sync> ;
	port = <0>;
	external_sync = <0>;
	data_order = <NX_VIN_Y0CBY1CR>;
	interlace = <0>;
	regulator_names = "axp22_dldo2";
	regulator_voltages = <1800000>;

	gpios = <&gpio_c 4 0
		 &gpio_c 5 0
		 &gpio_c 6 0>;

	sensor {
		type = <NX_CAPTURE_SENSOR_I2C>;
		i2c_name = "SP2518";
		i2c_adapter = <0>;
		addr = <0x30>;
	};

	power {
		enable_seq = <
		NX_ACTION_START NX_ACTION_TYPE_GPIO 2 1 0 NX_ACTION_END
		NX_ACTION_START NX_ACTION_TYPE_PMIC 0 0 NX_ACTION_END
		NX_ACTION_START NX_ACTION_TYPE_PMIC 1 0 NX_ACTION_END
		NX_ACTION_START NX_ACTION_TYPE_GPIO 0 0 0 1 0 NX_ACTION_END
		NX_ACTION_START NX_ACTION_TYPE_CLOCK 1 10 NX_ACTION_END
		NX_ACTION_START NX_ACTION_TYPE_GPIO 0 0 0 NX_ACTION_END
		NX_ACTION_START NX_ACTION_TYPE_GPIO 1 1 0 0 1 NX_ACTION_END
		NX_ACTION_START NX_ACTION_TYPE_GPIO 1 1 100 NX_ACTION_END
		>;
	};
};
&rtc {
	status = "okay";
};
&tmuctrl_0 {
	status = "okay";
};
&i2s_0 {
	#sound-dai-cells = <1>;
	sample-rate = <48000>;
	frame-bit = <32>;
	status = "okay";
};
&spdif_tx {
	#sound-dai-cells = <1>;
	status = "okay";
};
&adc {
	status = "okay";
};
&scaler {
	status = "okay";
};
&dvfs {
	supply_name = "vdd_arm_spu";
	supply_optional = "vdd_arm_axp";
	vdd_arm_spu-supply = <&VCC1P1_ARM_SPU>;
	vdd_arm_axp-supply = <&VCC1P1_ARM_PMIC>;
	status = "okay";
	dvfs-tables = <1400000 1200000
			1300000 1140000
			1200000 1100000
			1100000 1040000
			1000000 1040000
			900000 1000000
			800000 1000000
			700000 980000
			600000 980000
			500000 940000
			400000 940000>;
};
&dp_drm {
	status = "okay";
	ports {
		port@0 {
			reg = <0>;
			back_color = < 0x0 >;
			color_key = < 0x0 >;
			plane-names = "video", "rgb", "primary";
		};
		port@1 {
			reg = <1>;
			back_color = < 0x0 >;
			color_key = < 0x0 >;
			plane-names = "video", "primary";
		};
	};
};
&dp_drm_rgb {
	/*remote-endpoint = <&lcd_panel>;*/
	status = "ok";
	port {
		lcd_rgb: endpoint {
			remote-endpoint = <&rgb_panel>;
		};
	};

	dp_control {
                /*clk_src_lv0 = <0>;*/
                clk_src_lv0 = <3>;
                clk_div_lv0 = <16>;
                clk_src_lv1 = <7>;
                clk_div_lv1 = <1>;
                /*out_format = <3>;*/
                out_format = <2>;
                invert_field = <0>;
                swap_rb = <0>;
                yc_order = <0>;
                delay_mask = < ((1<<0) | (1<<1) | (1<<2) | (1<<3)) >;
                d_rgb_pvd = <0>;
                d_hsync_cp1 = <0>;
                d_vsync_fram = <0>;
                /*
                d_de_cp2 = <7>;
                vs_start_offset = <863>;
                ev_start_offset = <863>;
                */
                d_de_cp2 = <0>;
                vs_start_offset = <0>;
                ev_start_offset = <0>;
                vs_end_offset = <0>;
                ev_end_offset = <0>;
	};

};
&dp_drm_hdmi {
	skip-boot-connect;
	ddc-i2c-bus = <&i2c_1>;
	status = "ok";

	mode {
		width = <1280>;
		height = <720>;
		refresh = <60>;
	};
};
&i2c0_pin {
	nexell,pin-strength = <NX_PIN_STR1>;
};
&spi_0 {
	status = "okay";
	cs-gpios = <&gpio_c 30 0>;

	spidev0: spidev@0 {
		status = "okay";
		compatible = "linux,spidev";
		reg = <0>;
		spi-max-frequency = <10000000>;
		controller-data {
			samsung,spi-feedback-delay = <0>;
		};
	};

	t28tft0: fbtft@0 {
		status = "disabled";
		compatible = "sitronix,st7789v";
		reg = <0>;
		spi-max-frequency = <50000000>;
		rotate = <90>;
		fps = <33>;
		buswidth = <8>;
		dc-gpios = <&gpio_b 28 0>;
		reset-gpios = <&gpio_d 8 0>;
		debug = <0x0>;
		controller-data {
			samsung,spi-feedback-delay = <0>;
		};
	};
};
